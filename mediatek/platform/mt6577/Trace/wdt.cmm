d.s A:0xC0000000 %LE %LONG 0x00002224
